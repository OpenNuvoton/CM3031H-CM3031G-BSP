# IAR project XOMLib.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XOMLib.bin
  postbuild: cmd.exe /c echo "..\xomconv.exe" "$PROJ_PATH$"  ..\xomapi.h ..\lib\xomlib "$EW_DIR$" > makexom.bat
  ILINK.IlinkOutputFile: XOMLib.out
  ILINK.IlinkIcfFile: xom.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Src
    ../: xomlibIAR.c
