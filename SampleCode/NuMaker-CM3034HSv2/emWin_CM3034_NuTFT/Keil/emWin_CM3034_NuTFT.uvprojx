# Keil uVision project emWin_CM3034_NuTFT.uvprojx, settings and files
target emWin_CM3034_NuTFT (6240000::V6.24::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroCM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x50000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: emWin_CM3034_NuTFT +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\Library\StdDriver\inc;..\Config;..\Board;..\Application;..\ThirdParty\emWin_V656\GUI\Core;..\ThirdParty\emWin_V656\GUI\DisplayDriver;..\ThirdParty\emWin_V656\GUI\Widget;..\ThirdParty\emWin_V656\GUI\WM;..\ThirdParty\emWin_V656\GUI\MemDev
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm3031\Config\cm3031_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: system_cm3031.c startup_cm3031.c
  group User
    ../: main.c
    ../Application/: Demo_UI.c Boot_Screen.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c timer.c uart.c llsi.c
  group emWin_config
    ../Config/: GUI_X.c GUIConf.c LCDConf.c
  group emWin_lib
    ../Lib/: GUI_CM3034_AC6.lib
  group lcd
    ../../../../Library/StdDriver/src/: spi.c gpio.c i2c.c eadc.c
    ../Board/: LCD_Port.c Touch_Port.c Keys_Port.c Joystick_Port.c ARGB_Port.c
