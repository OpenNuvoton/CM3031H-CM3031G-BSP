# IAR project Secure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; DEBUG_PORT=UART0_NS
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AExtraOptionsV2: --cmse
  OBJCOPY.OOCOutputFile: Secure.bin
  postbuild: cmd.exe /c copy "Release\Exe\nsclib_Secure_IAR.o" "..\lib"
  ILINK.IlinkOutputFile: Secure.out
  ILINK.IlinkIcfFile: CM3031_s.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c
  group User
    ../: main.c
