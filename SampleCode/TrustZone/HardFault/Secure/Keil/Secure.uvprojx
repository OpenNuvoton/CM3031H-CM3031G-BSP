# Keil uVision project Secure.uvprojx, settings and files
target Secure (6220000::V6.22::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.3
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEBUG_PORT=UART0_NS
  c include: ..\..\;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\;..\..\..\..\..\Library\Device\Nuvoton\cm3031\Config;..\..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib_Secure.o
  group CMSIS
    ../../../../../Library/Device/Nuvoton/cm3031/Source/: system_cm3031.c startup_cm3031.c
  group User
    ../: main.c
    ../../: partition_cm3031.h
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c clk.c gpio.c
