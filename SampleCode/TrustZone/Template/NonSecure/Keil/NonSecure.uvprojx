# Keil uVision project NonSecure.uvprojx, settings and files
target Nonsecure (6240000::V6.24::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroCM33_DFP.1.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Nonsecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: DEBUG_PORT=UART1_NS, __NONSECURE_CODE=1
  c include: ..\..\;..\..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\..\Library\CMSIS\Core\Nuvoton\cm3031\Include;..\..\..\..\..\Library\StdDriver\inc;..\..\Nonsecure
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: nonsecure.sct
  group CMSIS
    ../../../../../Library/CMSIS/Core/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group User
    ../: main_ns.c
  group Library
    ../../../../../Library/StdDriver/src/: retarget.c gpio.c
    ../../Secure/lib/: nsclib_Secure.o
