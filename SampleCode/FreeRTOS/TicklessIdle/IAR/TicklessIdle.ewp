# IAR project TicklessIdle.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\include; ..\..\..\..\ThirdParty\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\ThirdParty\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\ThirdParty\FreeRTOS\include
  OBJCOPY.OOCOutputFile: TicklessIdle.bin
  ILINK.IlinkOutputFile: TicklessIdle.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/Nuvoton/M333xxIGAE.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Demo App Source
    ../: FreeRTOSConfig.h main.c ParTest.c
    ../../../../ThirdParty/FreeRTOS/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group FreeRTOS source
    ../../../../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../ThirdParty/FreeRTOS/: list.c queue.c tasks.c timers.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c rtc.c sys.c uart.c
  group System
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
