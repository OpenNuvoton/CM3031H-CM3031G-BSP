# Keil uVision project Blinky.uvprojx, settings and files
target FreeRTOS (6240000::V6.24::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroCM33_DFP.1.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000)
  output: FreeRTOS
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\..\..\..\Library\Device\Nuvoton\cm3031\Config;..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FreeRTOS\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\..\..\ThirdParty\FreeRTOS\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\Blinky
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm3031\Config\cm3031_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group System
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group Demo Files
    ../: FreeRTOSConfig.h main.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/: tasks.c timers.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../../../../ThirdParty/FreeRTOS/portable/MemMang/: heap_2.c
  group lib
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c gpio.c
