# IAR project Blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDiagSuppress: Pa082, Pe111
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FreeRTOS\include; ..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include; ..\..\..\..\ThirdParty\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\ThirdParty\FreeRTOS\include; C:\MCU_MS20\MAG071_CM3031\cm3031bsp\Library\Device\Nuvoton\cm3031\Include
  OBJCOPY.OOCOutputFile: Blinky.bin
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group FreeRTOS files
    ../../../../ThirdParty/FreeRTOS/portable/MemMang/: heap_2.c
    ../../../../ThirdParty/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../../ThirdParty/FreeRTOS/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
