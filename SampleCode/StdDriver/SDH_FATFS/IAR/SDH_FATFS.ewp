# IAR project SDH_FATFS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082, Pe068
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\ThirdParty\FatFs\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDH_FATFS.bin
  ILINK.IlinkOutputFile: SDH_FATFS.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sdh.c sys.c timer.c uart.c
  group User
    ../: diskio.c main.c SDGlue.c
