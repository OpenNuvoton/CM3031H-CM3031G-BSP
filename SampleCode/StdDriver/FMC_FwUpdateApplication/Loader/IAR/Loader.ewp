# IAR project Loader.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\..\Library\StdDriver\inc; ..\..\common\inc; ..\..\..\..\..\Library\NuMaker\xmodem
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Loader.bin
  ILINK.IlinkOutputFile: Loader.out
  ILINK.IlinkIcfFile: Loader.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group Library
    ../../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
    ../../../../../Library/NuMaker/xmodem/: xmodem.c
  group User
    ../: main.c
