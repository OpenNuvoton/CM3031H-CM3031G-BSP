# IAR project CANFD_CANFD_MonitorMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CANFD_CANFD_MonitorMode.bin
  ILINK.IlinkOutputFile: CANFD_CANFD_MonitorMode.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group Library
    ../../../../Library/StdDriver/src/: canfd.c clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
