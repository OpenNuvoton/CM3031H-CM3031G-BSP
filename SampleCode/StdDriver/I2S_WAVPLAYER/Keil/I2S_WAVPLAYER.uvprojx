# Keil uVision project I2S_WAVPLAYER.uvprojx, settings and files
target I2S_WAVPLAYER (6230000::V6.23::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroCM33_DFP.1.0.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M33") FPU2
  output: I2S_WAVPLAYER
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\..\..\..\Library\Device\Nuvoton\cm3031\Config;..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source
  asm define: Stack_Size=0x4000 Heap_Size=0x1000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm3031\Config\cm3031_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: system_cm3031.c startup_cm3031.c
  group Source
    ../: main.c diskio.c wavplayer.c isr.c sdglue.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c i2s.c i2c.c clk.c uart.c retarget.c pdma.c sdh.c gpio.c
  group FATFS
    ../../../../ThirdParty/FatFs/source/: ff.c
