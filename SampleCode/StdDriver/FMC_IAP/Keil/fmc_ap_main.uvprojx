# Keil uVision project fmc_ap_main.uvprojx, settings and files
target fmc_ap_main (6230000::V6.23::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroCM33_DFP.1.0.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: fmc_ap_main
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\;..\..\..\..\Library\Device\Nuvoton\cm3031\Config;..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm3031\Config\cm3031_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group User
    ../: APROM_main.c
    ./: ap_image.S
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c fmc.c
