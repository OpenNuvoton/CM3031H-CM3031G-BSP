# IAR project HSOTG_HNP.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HSOTG_HNP.bin
  ILINK.IlinkOutputFile: HSOTG_HNP.out
  ILINK.IlinkIcfFile: HSOTG_HNP.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c hsusbd.c retarget.c sys.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_HID
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c hid_driver.c
  group User
    ../: descriptors.c hid_mouse.c main.c
