# IAR project SYS_SPDMode_WakeupVTOR.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M333xxIGAE series Nuvoton M333xxIGAE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Core\Include; ..\..\..\..\Library\Device\Nuvoton\cm3031\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_SPDMode_WakeupVTOR.bin
  ILINK.IlinkOutputFile: SYS_SPDMode_WakeupVTOR.out
  ILINK.IlinkIcfFile: SYS_SPDMode_WakeupVTOR.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../: mystartup_cm3031_IAR.s
    ../../../../Library/Device/Nuvoton/cm3031/Source/: system_cm3031.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c rtc.c sys.c uart.c
  group User
    ../: main.c
