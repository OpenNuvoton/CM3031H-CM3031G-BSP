# Keil uVision project ISP_CAN.uvprojx, settings and files
target ISP_CAN (6220000::V6.22::ARMCLANG)
  device: CM3034HS8AE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.0
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000)
  output: ISP_CAN
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\;..\..\..\..\Library\Device\Nuvoton\cm3031\Config;..\..\..\..\Library\Device\Nuvoton\cm3031\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\cm3031\Config\cm3031_ac6.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/cm3031/Source/: startup_cm3031.c system_cm3031.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: canfd.c fmc.c sys.c clk.c
